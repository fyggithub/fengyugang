# Keil uVision project stm32_app.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_boot +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Headers;.\Libraies\inc;.\System\inc;.\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/src/: usart.c wdg.c main.c stm32f10x_it.c flash.c common_init.c process.c gpio.c cpld.c myiic.c
  group Header
    ./Headers/: stm32f10x_conf.h stm32f10x_it.h
    ./User/inc/: gpio.h
  group Libraries/src
    ./Libraies/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group System/src
    ./System/src/: debug_usart.c delay.c sys.c irq_handler.c

# Keil uVision project stm32_app.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_app +hex
  AfterMake: D:\software_path\keil\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/stm32_app.bin ./Output/stm32_app.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Headers;.\Libraies\inc;.\System\inc;.\User\inc;.\User\src\it6662;.\User\src\it6662\IT6662_Customer;.\User\src\it6662\IT6662_Source
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/src/: common_init.c eeprom.c flash.c process.c gpio.c lcd.c lm75.c main.c myiic.c spi.c stm32f10x_it.c timer.c usart.c wdg.c ir.c fan.c led.c tmds181.c ds1339c.c oled.c Buffer.c
    ./User/src/it6662/: IT6662_IT6350_Main.c IO_IT6350.c
    ./User/src/it6662/IT6662_Source/: Cec.c Csc.c Edid.c Hdmi_Rx.c Hdmi_Tx.c IT6662.c Mhl_Msc.c Mhl_Rx.c
    ./User/src/it6662/IT6662_Customer/: CecRx_Handler.c CecTx_Handler.c IT6662_1to4.c IT6662_IO.c Mhl_RcpUcpHandler.c
  group Header
    ./Headers/: stm32f10x_it.h stm32f10x_conf.h
    ./User/inc/: common_init.h eeprom.h flash.h gpio.h lcd.h lm75.h myiic.h process.h spi.h timer.h usart.h wdg.h ir.h fan.h led.h tmds181.h ds1339c.h oled.h it6662.h Bits.h Buffer.h Datatypes.h
  group Libraries/src
    ./Libraies/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group System/src
    ./System/src/: debug_usart.c delay.c irq_handler.c sys.c
